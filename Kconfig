## Kconfig
```kconfig
mainmenu "Lumen Kernel Configuration"

source "arch/Kconfig"

menu "Kernel features"

source "kernel/Kconfig"

endmenu
```
